# Keil uVision project cm3_demo.uvprojx, settings and files
target Project (6180000::V6.18::ARMCLANG)
  device: DS_CM3 ARM
  pack: Keil.V2M-MPS2_DSx_BSP.1.1.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: cm3_demo +hex
  AfterMake: fromelf --bin --output ./Objects/cm3_demo.bin ./Objects/cm3_demo.axf
  AfterMake: fromelf --text -a -c --output ./Objects/cm3_demo.dis ./Objects/cm3_demo.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Peripheral\ZGPIO;.\System\delay;.\Hardware\LED;.\Peripheral\ZUART;.\Hardware\SPI
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: main.c
  group System
    ./System/delay/: delay.c
  group Peripheral
    ./Peripheral/ZGPIO/: ZGPIO.c
    ./Peripheral/ZUART/: ZUART.c
  group Hardware
    ./Hardware/LED/: led.c
    ./Hardware/SPI/: spi.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
